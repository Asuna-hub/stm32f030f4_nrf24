# Keil uVision project nrf24_stm32f0.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf24_stm32f0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Src
    ./: main.c rcc.c systick.c spi.c nrf24.c
  group Inc
    ./: main.h rcc.h systick.h spi.h nrf24.h nrf24_n.h
software components: CMSIS:CORE 6.1.1, Device:Startup 2.2.3
